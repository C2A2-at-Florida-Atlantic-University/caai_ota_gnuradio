options:
  parameters:
    author: Jose Sanchez
    generate_options: qt_gui
    id: FileWrite_RX
    output_language: python
    title: FileWrite_RX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/josea/Documents/ota_gnuradio/caai_ota_gnuradio/Matlab/BPSK.dat
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: RX
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: RX
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: TX
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
