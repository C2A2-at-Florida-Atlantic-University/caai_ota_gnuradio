options:
  parameters:
    author: Jose Sanchez
    generate_options: qt_gui
    id: FileWrite_RX
    output_language: python
    title: FileWrite_RX
  states: {}

blocks:
- name: Bandwidth
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: Freq
  id: variable
  parameters:
    value: 3.555e9
  states: {}
- name: Gain
  id: variable
  parameters:
    value: '31'
  states: {state: disabled}
- name: Gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '31'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"TX Time Sink"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: Bandwidth
    center_freq0: Freq
    dev_args: '""'
    gain0: Gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
