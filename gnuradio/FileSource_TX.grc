options:
  parameters:
    author: Jose Sanchez
    generate_options: no_gui
    id: FileSource_TX
    output_language: python
    title: FileSource_TX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /local/caai_ota_gnuradio/Matlab/data_DSB-AM.dat
    repeat: 'False'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 0.5e6
    center_freq0: 3.555e9
    dev_args: '""'
    gain0: '31'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
