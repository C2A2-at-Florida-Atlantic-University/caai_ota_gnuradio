options:
  parameters:
    author: Jose Sanchez
    generate_options: qt_gui
    id: FileWrite_RX
    output_language: python
    title: FileWrite_RX
  states: {}

blocks:
- name: Bandwidth
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: Freq
  id: variable
  parameters:
    value: 3.555e9
  states: {}
- name: Gain
  id: variable
  parameters:
    value: '36'
  states: {state: disabled}
- name: Gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '36'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX Frequency Sink"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"RX Time Sink"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: Bandwidth
    center_freq0: Freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: Gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
